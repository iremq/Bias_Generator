v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {opin.sym} 0 0 0 0 {name=p_mbias_bus lab=MBIAS[1:0]}
C {vsource.sym} 0 170 0 0 {name=V1 value=3 savecurrent=false}
C {gnd.sym} 0 200 0 0 {name=l1 lab=0}
C {lab_pin.sym} 0 140 0 0 {name=p_mbias_bus1 lab=MBIAS[0]}
C {vsource.sym} 130 170 0 0 {name=V2 value=1 savecurrent=false}
C {gnd.sym} 130 200 0 0 {name=l2 lab=0}
C {lab_pin.sym} 130 140 0 0 {name=p_mbias_bus2 lab=MBIAS[1]}
